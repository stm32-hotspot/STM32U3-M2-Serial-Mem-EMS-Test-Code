# IAR project Naquada.ewp, settings and files
configuration M2 Memory (ARM, debug)
  General.OGChipSelectEditMenu: STM32U385VG ST STM32U385VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32U385xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32U3xx_HAL_Driver/Inc; ../Drivers/STM32U3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32U3xx/Include; ../Drivers/CMSIS/Include; ..\Appli; ..\Baseline; ..\Bus; ..\Interconnect; ..\Parts; ..\Boards; ..\Parts\VL53L8CX
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B-M2MEM-PACK1_test.hex
  ILINK.IlinkOutputFile: Naquada.out
  ILINK.IlinkIcfFile: stm32u385xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u385xx.s
  group Application/User/Appli
    ../Appli/: app.c app.h
  group Application/User/Baseline
    ../Baseline/: commons.c commons.h critical.h io_drive.c io_drive.h pfifo.c pfifo.h STM32U3LQFP100_SMPS.c STM32U3LQFP100_SMPS.h u8fifo.c u8fifo.h
  group Application/User/Boards
    ../Boards/: BoardSet.c BoardSet.h MB2095_MCU.c MB2095_MCU.h MB2095_NET.h MB2095_SENSORS.c MB2095_SENSORS.h MB2095B_MCU.c MB2095B_MCU.h MB2095B_NET.h MB2095B_SENSORS.c MB2095B_SENSORS.h naquada_board.c naquada_board.h
  group Application/User/BUS
    ../Bus/: I2C_MasterIO.c I2C_MasterIO.h SerialComPort.c SerialComPort.h SPI_MasterIO.c SPI_MasterIO.h
  group Application/User/Core
    ../Core/Src/: main.c stm32u3xx_hal_msp.c stm32u3xx_it.c
    ../Core/Inc/: main.h
  group Application/User/Parts
    ../Parts/: LEDs.c LEDs.h lis2du12_reg.c lis2du12_reg.h M24256D.c M24256D.h M2SM_AP256XXN_OBR.c M2SM_APS6404L.c M2SM_APS6404L.h M2SM_APS6404L_SQN.c M2SM_EEP_PNP.c M2SM_EEP_PNP.h M2SM_EM128LX.c M2SM_EM128LX.h M2SM_IS25LP032.h M2SM_IS25LP032D.c M2SM_IS66WVJ8M8F.c M2SM_M95P32.c M2SM_M95P32.h M2SM_MX25LM51245G.c M2SM_MX25LM51245G.h M2SM_MX25UM51245G.c M2SM_MX25UM51245G.h M2SM_MX35LF4GEAD.c M2SM_NOR.c M2SM_NOR.h M2SM_S28HS512TGABHI01.c M2SM_W25Q128JV.c M2SM_W25Q16JV.c M2SM_W25Q16JV.h platform.c platform.h SerialMem.c SerialMem.h sths34pf80_reg.c sths34pf80_reg.h support_MX_DTR_snippet.c VL53L4CD_api.c VL53L4CD_api.h VL53L4CD_calibration.c
  group Application/User/Parts/VL53L8CX
    ../Parts/VL53L8CX/: vl53l8cx_api.c vl53l8cx_api.h vl53l8cx_buffers.h vl53l8cx_platform.c vl53l8cx_platform.h vl53l8cx_plugin_detection_thresholds.c vl53l8cx_plugin_detection_thresholds.h vl53l8cx_plugin_motion_indicator.c vl53l8cx_plugin_motion_indicator.h vl53l8cx_plugin_xtalk.c vl53l8cx_plugin_xtalk.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u3xx.c
  group Drivers/STM32U3xx_HAL_Driver
    ../Drivers/STM32U3xx_HAL_Driver/Src/: stm32u3xx_hal.c stm32u3xx_hal_adc.c stm32u3xx_hal_adc_ex.c stm32u3xx_hal_cortex.c stm32u3xx_hal_dac.c stm32u3xx_hal_dac_ex.c stm32u3xx_hal_dma.c stm32u3xx_hal_dma_ex.c stm32u3xx_hal_exti.c stm32u3xx_hal_flash.c stm32u3xx_hal_flash_ex.c stm32u3xx_hal_gpio.c stm32u3xx_hal_gtzc.c stm32u3xx_hal_icache.c stm32u3xx_hal_lptim.c stm32u3xx_hal_pwr.c stm32u3xx_hal_pwr_ex.c stm32u3xx_hal_rcc.c stm32u3xx_hal_rcc_ex.c stm32u3xx_hal_rtc.c stm32u3xx_hal_rtc_ex.c stm32u3xx_hal_tim.c stm32u3xx_hal_tim_ex.c stm32u3xx_hal_uart.c stm32u3xx_hal_uart_ex.c stm32u3xx_hal_xspi.c stm32u3xx_ll_dlyb.c stm32u3xx_ll_dma.c stm32u3xx_ll_exti.c stm32u3xx_ll_gpio.c stm32u3xx_ll_rcc.c stm32u3xx_ll_usart.c stm32u3xx_ll_utils.c
